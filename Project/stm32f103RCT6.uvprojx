# Keil uVision project stm32f103RCT6.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103RCT6 +hex
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,EMPL_TARGET_STM32F1,MPU6050,HSE_VALUE=8000000
  c include: ..\Core;..\FWLib\inc;..\User;..\Startup;..\Middlewares\FreeRTOS\include;..\Middlewares\FreeRTOS\portable\RVDS\ARM_CM3;..\User\app\bsp;..\User\app\algo;..\User\app\sys;..\User\app\tasks;..\User\Modules\mpu6050;..\User\Modules\dw1000
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Startup
    ../Startup/: startup_stm32f10x_hd.s
  group CMSIS_Core
    ../Core/: core_cm3.c system_stm32f10x.c
  group StdPeriph
    ../FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group FreeRTOS
    ../Middlewares/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../Middlewares/FreeRTOS/portable/MemMang/: heap_4.c
  group User
    ../User/: main.c syscalls.c stm32f10x_it.c
  group App_Sys
    ../User/app/sys/: error.c health.c scheduler.c
  group App_Algo
    ../User/app/algo/: pid.c filter.c alarm.c safety_fsm.c uwb_2d.c bcm_door.c
  group App_BSP
    ../User/app/bsp/: Delay.c Key.c LED.c oled.c bsp_adc.c bsp_at24c256.c bsp_esp8266.c bsp_motor.c bsp_rtc.c bsp_usart.c bsp_uwb.c bsp_watchdog.c bsp_can.c
  group App_Tasks
    ../User/app/tasks/: control_task.c monitor_task.c uwb_task.c hmi_task.c comm_task.c housekeep_task.c bcm_task.c
  group Modules_MPU6050
    ../User/Modules/mpu6050/: MPU6050.c inv_mpu.c inv_mpu_dmp_motion_driver.c mpu_port.c
